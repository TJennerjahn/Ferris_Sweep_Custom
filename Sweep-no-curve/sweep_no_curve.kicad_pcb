# Repository TJennerjahn/Ferris_Sweep_Custom

## KiCad design Sweep-no-curve/sweep_no_curve.kicad_pcb

Board: 2 copper layers, 111.7 x 88.2 mm, 22 parts (0 on the bottom side), 21 nets.

Parts:
B+: MountingHole_Pad; 1pin_conn
B-: MountingHole_Pad; 1pin_conn
POWER SW: SW_SPDT; SPDT_C128955
RSW2: SW_Push; Tactile-Switch_SMT
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17: SW_Push; Kailh_socket_PG1350_optional_reversible
U1: ProMicro-kbd; ProMicro_jumpers_facedown

Connections:
BT+_r: B+.1, POWER SW.2
Switch1: SW1.1, U1.10
Switch2: SW2.1, U1.17
Switch3: SW3.1, U1.18
Switch4: SW4.1, U1.19
Switch5: SW5.1, U1.20
Switch6: SW6.1, U1.16
Switch7: SW7.1, U1.15
Switch8: SW8.1, U1.14
Switch9: SW9.1, U1.13
Switch10: SW10.1, U1.1
Switch11: SW11.1, U1.5
Switch12: SW12.1, U1.6
Switch13: SW13.1, U1.7
Switch14: SW14.1, U1.8
Switch15: SW15.1, U1.9
Switch16: SW16.1, U1.11
Switch17: SW17.1, U1.12
gnd: B-.1, RSW2.1, RSW2.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.2, SW17.2, U1.3, U1.4, U1.23
raw: POWER SW.3, U1.24
reset: RSW2.1, RSW2.2, U1.22

## Commit log

2022-08-31 add customization starting point
2022-09-02 Sweep Version without the top sweep, kailh hotswap support and bluetooth only (no trrs jack)
